# KOMPAS-3D part (ZARDP 065.016.40.P.m3d)

Model tree:
1. Булева операция:3
2. Булева операция:4
